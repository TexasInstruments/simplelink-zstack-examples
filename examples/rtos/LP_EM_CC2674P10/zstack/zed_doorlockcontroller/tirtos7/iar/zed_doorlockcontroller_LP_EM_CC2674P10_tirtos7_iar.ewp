# IAR project zed_doorlockcontroller_LP_EM_CC2674P10_tirtos7_iar.ewp, settings and files
configuration default (ARM)
  General.OGChipSelectEditMenu: Default None
  General.CoreVariant: 59
  General.FPU2: 6
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 2
  group (top)
    ./: zed_doorlockcontroller_LP_EM_CC2674P10_tirtos7_iar.ipcf SysConfig_Generated_Files.ipcf

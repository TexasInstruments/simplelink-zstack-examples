# IAR project zed_sw_ota_client_offchip_LP_CC2652RSIP_tirtos7_iar.ewp, settings and files
configuration default (ARM)
  General.OGChipSelectEditMenu: Default None
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 2
  group (top)
    ./: zed_sw_ota_client_offchip_LP_CC2652RSIP_tirtos7_iar.ipcf SysConfig_Generated_Files.ipcf
